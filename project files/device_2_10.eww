<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\v.10.x.y\device_2_v_10_0_2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


